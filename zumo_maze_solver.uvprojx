# Keil uVision project zumo_maze_solver.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x1FFFE000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: zumo_maze_solver
  c flags: Optim=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group Source Group 1
    ./: bluetooth.c leds.c main.c motorDriver.c zumo_button.c zumo_buzzer.c zumo_ledArray.c zumo_maze.c bluetooth.h leds.h motorDriver.h zumo_button.h zumo_buzzer.h zumo_ledArray.h zumo_maze.h
  group ::Device
    RTE/Device/MKL46Z256xxx4/: startup_MKL46Z4.s system_MKL46Z4.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
